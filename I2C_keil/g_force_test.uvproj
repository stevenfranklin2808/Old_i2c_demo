# Keil uVision project g_force_test.uvproj, settings and files
target nRF51822AA (ARM-ADS)
  device: nRF51xxx Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: g_force_test +hex
  c flags: Optim=1
  c define: TARGET_NRF51822,  TARGET_M0,  TARGET_CORTEX_M,  TARGET_NORDIC,  TARGET_NRF51822_MKIT,  TARGET_MCU_NRF51822,  TARGET_MCU_NORDIC_16K,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,  MBED_BUILD_TIMESTAMP=1436908042.74,  __MBED__=1,  NRF51,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  mbed;  mbed/TARGET_NRF51822;  mbed/TARGET_NRF51822/TARGET_NORDIC;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/sd_common;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/app_common;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API/include;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT;  mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD;  BB_Final_full;  BB_Final_full/H3LIS331DL;  BB_Final_full/I2C_LIB;  BB_Final_full/nRF51822;  BB_Final_full/nRF51822/common;  BB_Final_full/nRF51822/btle;  BB_Final_full/nRF51822/btle/custom;  BB_Final_full/nRF51822/nordic;  BB_Final_full/nRF51822/nordic/ble;  BB_Final_full/nRF51822/nordic/ble/ble_services;  BB_Final_full/nRF51822/nordic/bootloader_dfu;  BB_Final_full/nRF51822/nordic/nrf-sdk;  BB_Final_full/nRF51822/nordic/nrf-sdk/sd_common;  BB_Final_full/nRF51822/nordic/nrf-sdk/ble;  BB_Final_full/nRF51822/nordic/nrf-sdk/ble/ble_services;  BB_Final_full/nRF51822/nordic/nrf-sdk/ble/device_manager;  BB_Final_full/nRF51822/nordic/nrf-sdk/bootloader_dfu;  BB_Final_full/nRF51822/nordic/nrf-sdk/app_common;  BB_Final_full/nRF51822/nordic/nrf-sdk/s110;  BB_Final_full/nRF51822/nordic/app_common;  BB_Final_full/MPU3050;  BB_Final_full/SPI_LIB;  BB_Final_full/BLE_API;  BB_Final_full/BLE_API/common;  BB_Final_full/BLE_API/services;  BB_Final_full/BLE_API/public;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/nRF51822.sct
  link misc: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/system_nrf51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/startup_nRF51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    BB_Final_full/nRF51822/nordic/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
    BB_Final_full/nRF51822/nordic/app_common/: app_scheduler.c hci_mem_pool.c app_gpiote.c crc16.cpp pstorage.cpp
    BB_Final_full/: main.cpp
    BB_Final_full/H3LIS331DL/: H3LIS331DL.cpp
    BB_Final_full/I2C_LIB/: I2C_LIB.cpp
    BB_Final_full/nRF51822/: nRF51Gap.cpp nRF51GattServer.cpp nRF51822n.cpp
    BB_Final_full/nRF51822/btle/: btle_gap.cpp btle_advertising.cpp btle.cpp
    BB_Final_full/nRF51822/btle/custom/: custom_helper.cpp
    BB_Final_full/nRF51822/nordic/: softdevice_handler.cpp
    BB_Final_full/nRF51822/nordic/ble/: ble_advdata_parser.cpp ble_conn_params.cpp ble_bondmngr.cpp ble_error_log.cpp ble_debug_assert_handler.cpp ble_advdata.cpp
    BB_Final_full/nRF51822/nordic/ble/ble_services/: ble_srv_common.cpp
    BB_Final_full/MPU3050/: MPU3050.cpp
    BB_Final_full/SPI_LIB/: SPI_LIB.cpp
    BB_Final_full/BLE_API/common/: UUID.cpp GapAdvertisingParams.cpp GattService.cpp BLEDevice.cpp GapAdvertisingData.cpp
    BB_Final_full/BLE_API/services/: UARTService.cpp DFUService.cpp
